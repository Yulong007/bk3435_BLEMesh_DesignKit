# Keil uVision project bk3435.uvproj, settings and files
target BK3435_app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk3435_ble_app
  AfterMake: fromelf --bin --output .\output\app\bk3435_ble_app.bin .\obj\bk3435_ble_app.axf
  AfterMake: .\output\encrypt_app.bat
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: CONFIG_AOS_CLI
  c misc: --c99 --gnu --diag_suppress 177,174
  c include: ..\..\sdk\plactform\src\arch;..\..\sdk\plactform\src\arch\boot;..\..\sdk\plactform\src\arch\compiler;..\..\sdk\plactform\src\arch\ll;..\..\sdk\plactform\src\core_modules\arch_console;..\..\sdk\plactform\src\core_modules\common\api;..\..\sdk\plactform\src\core_modules\dbg\api;..\..\sdk\plactform\src\core_modules\ecc_p256\api;..\..\sdk\plactform\src\core_modules\rf\api;..\..\sdk\plactform\src\include;..\..\sdk\plactform\src\driver\timer;..\..\sdk\plactform\src\driver\reg;..\..\sdk\plactform\src\driver\emi;..\..\sdk\plactform\src\driver\intc;..\..\sdk\plactform\src\driver\syscntl;..\..\sdk\plactform\src\driver\flash;..\..\sdk\plactform\src\driver\counter;..\..\sdk\plactform\src\driver\intcntl;..\..\sdk\plactform\src\driver\uart;..\..\sdk\plactform\src\driver\gpio;..\..\sdk\plactform\src\driver\adc;..\..\sdk\plactform\src\driver\spi;..\..\sdk\plactform\src\driver\icu;..\..\sdk\plactform\src\driver\plf;..\..\sdk\plactform\src\driver\wdt;..\..\sdk\plactform\src\rom\hci;..\..\sdk\ble_stack_com\prf;..\..\sdk\ble_stack_com\profiles;..\..\sdk\ble_stack_com\profiles\FFF0\api;..\..\sdk\ble_stack_com\profiles\oad\api;..\..\sdk\ble_stack_com\profiles\dis\diss\src;..\..\sdk\ble_stack_com\profiles\dis\diss\api;..\..\sdk\ble_stack_com\profiles\bas\bass\src;..\..\sdk\ble_stack_com\profiles\bas\bass\api;..\..\sdk\ble_stack_com\rwble;..\..\sdk\ble_stack_com\rwble_hl;..\..\sdk\ble_stack_com\rwip\api;..\..\sdk\ble_stack_inc\ahi\api;..\..\sdk\ble_stack_inc\ea\api;..\..\sdk\ble_stack_inc\em\api;..\..\sdk\ble_stack_inc\h4tl\api;..\..\sdk\ble_stack_inc\hci\src;..\..\sdk\ble_stack_inc\hci\api;..\..\sdk\ble_stack_inc\ke\src;..\..\sdk\ble_stack_inc\ke\api;..\..\sdk\ble_stack_inc\nvds\api;..\..\sdk\ble_stack_inc\ble\ll\src\em;..\..\sdk\ble_stack_inc\ble\ll\src\llc;..\..\sdk\ble_stack_inc\ble\ll\src\lld;..\..\sdk\ble_stack_inc\ble\ll\src\llm;..\..\sdk\ble_stack_inc\ble\hl\api;..\..\sdk\ble_stack_inc\ble\hl\inc;..\..\sdk\ble_stack_inc\ble\hl\src\gap;..\..\sdk\ble_stack_inc\ble\hl\src\gap\gapc;..\..\sdk\ble_stack_inc\ble\hl\src\gap\gapm;..\..\sdk\ble_stack_inc\ble\hl\src\gap\smpc;..\..\sdk\ble_stack_inc\ble\hl\src\gap\smpm;..\..\sdk\ble_stack_inc\ble\hl\src\gatt;..\..\sdk\ble_stack_inc\ble\hl\src\gatt\attc;..\..\sdk\ble_stack_inc\ble\hl\src\gatt\attm;..\..\sdk\ble_stack_inc\ble\hl\src\gatt\atts;..\..\sdk\ble_stack_inc\ble\hl\src\gatt\gattc;..\..\sdk\ble_stack_inc\ble\hl\src\gatt\gattm;..\..\sdk\ble_stack_inc\ble\hl\src\l2c\l2cc;..\..\sdk\ble_stack_inc\ble\hl\src\l2c\l2cm;..\..\sdk\plactform\src\driver\audio;..\..\sdk\plactform\src\driver\pwm;..\..\sdk\plactform\src\driver\ir;..\..\sdk\mesh_inc\al;.\config;.\app;..\..\sdk\mesh_api\models;..\..\sdk\mesh_inc\al\aes;..\..\sdk\mesh_inc\al\lld;..\..\sdk\mesh_inc\api;..\..\sdk\mesh_inc\inc;..\..\sdk\mesh_inc\inc_al;..\..\sdk\mesh_inc\src;..\..\sdk\mesh_inc\src\common;..\..\sdk\mesh_inc\src\common\inc;..\..\sdk\mesh_inc\src\common\src;..\..\sdk\mesh_inc\src\common\src\tb;..\..\sdk\mesh_inc\src\inc;..\..\sdk\mesh_inc\src\models;..\..\sdk\mesh_inc\src\models\inc;..\..\sdk\mesh_inc\src\models\src;..\..\sdk\mesh_inc\src\models\src\route;..\..\sdk\mesh_inc\src\models\src\tb;..\..\sdk\mesh_inc\src\prf;..\..\sdk\mesh_inc\src\prf\inc;..\..\sdk\mesh_inc\src\prf\src;..\..\sdk\mesh_inc\src\prf\src\bcn;..\..\sdk\mesh_inc\src\prf\src\bearer;..\..\sdk\mesh_inc\src\prf\src\fnd;..\..\sdk\mesh_inc\src\prf\src\lay;..\..\sdk\mesh_inc\src\prf\src\prov;..\..\sdk\mesh_inc\src\prf\src\tb;..\..\sdk\mesh_inc\src\models\src\gen\gens;..\..\sdk\mesh_inc\src\models\src\light\lights;..\..\sdk\mesh_inc\mesh_param;..\..\sdk\ble_stack_inc;..\..\sdk\ble_stack_inc;..\..\sdk\mesh_inc\mesh_param;..\..\sdk\mesh_inc\inc;..\..\sdk\mesh_inc\inc;..\general_api
  asm include: .\src\plf\refip\src\arch\ll
  memory RVCT6: RAM 0x400000 size 0xc000
  scatter file: ..\..\sdk\project_files\gatt_link_app.txt
  link misc: --entry sys_Reset
  group System
    ./app/: arch_main.c
    ../../sdk/plactform/src/arch/boot/: boot_handlers.s boot_vectors.s
    ../../sdk/project_files/: stack_rom_symbol.txt
    ../../sdk/mesh_inc/src/common/src/: mesh_log.c
  group config
    ./config/: rwprf_config.h user_config.h
    ../../sdk/ble_stack_inc/: rwip_config.h
  group ip
    ../../sdk/ble_stack_com/rwble_hl/: rwble_hl.c
    ../../sdk/ble_stack_com/rwble/: rwble.c
    ../../sdk/ble_stack_com/rwip/src/: rwip.c
  group driver
    ../../sdk/plactform/src/driver/icu/: icu.c
    ../../sdk/plactform/src/driver/intc/: intc.c
    ../../sdk/plactform/src/driver/uart/: uart.c
    ../../sdk/plactform/src/driver/emi/: emi.c
    ../../sdk/plactform/src/driver/flash/: flash.c
    ../../sdk/plactform/src/driver/timer/: timer.c
    ../../sdk/plactform/src/core_modules/rf/src/: rf_xvr.c
    ../../sdk/plactform/src/driver/wdt/: wdt.c
    ../../sdk/plactform/src/driver/gpio/: gpio.c
    ../../sdk/plactform/src/driver/pwm/: pwm.c
  group profile
    ../../sdk/ble_stack_com/profiles/bas/bass/src/: bass.c bass_task.c
    ../../sdk/ble_stack_com/profiles/dis/diss/src/: diss.c diss_task.c
    ../../sdk/ble_stack_com/profiles/FFF0/src/: fff0s.c fff0s_task.c
    ../../sdk/ble_stack_com/profiles/oad/src/: oads.c oads_task.c
    ../../sdk/ble_stack_com/prf/: prf.c prf_utils.c
  group app
    ./app/: ali_config.c app_light_ali_server.c app.c app_batt.c app_dis.c app_fff0.c app_oads.c app_task.c app_mesh.c led.c app_mm_msg.c oad_common.c
    ../general_api/: mesh_general_api.c
  group lib
    ../../libs/: bk3435_fcc_mode.lib bk3435_pn9_mode.lib
    ../../libs/mesh lib/device/: bk3435_ble_mesh_log_warning.lib bk3435_ble_mesh_no_log.lib
  group mesh_api
    ../../sdk/mesh_api/m_api/: m_api.c m_api_msg.c
    ../../sdk/mesh_api/mesh_api/: mesh_api.c mesh_api_msg.c
    ../../sdk/mesh_api/mesh_param/: mesh_param_int.c
    ../../sdk/mesh_api/mm_api/: mm_api_msg.c mm_api.c
  group mesh_model
    ../../sdk/mesh_api/models/: m_fnd_BLOB_Transfer.c m_fnd_Fw_Update.c m_fnd_Scenes.c mm_vendors.c
  group models
    ../../sdk/mesh_inc/src/models/src/gen/gens/: mm_gens.c mm_gens_bat.c mm_gens_dtt.c mm_gens_loc.c mm_gens_lvl.c mm_gens_oo.c mm_gens_plvl.c mm_gens_poo.c mm_gens_prop.c
    ../../sdk/mesh_inc/src/models/src/light/lights/: mm_lights.c mm_lights_ctl.c mm_lights_hsl.c mm_lights_ln.c
  group modelc
    ../../sdk/mesh_inc/src/models/src/gen/genc/: mm_genc.c mm_genc_bat.c mm_genc_dtt.c mm_genc_loc.c mm_genc_lvl.c mm_genc_oo.c mm_genc_plvl.c mm_genc_poo.c mm_genc_prop.c
    ../../sdk/mesh_inc/src/models/src/light/lightc/: mm_lightc.c mm_lightc_ctl.c mm_lightc_hsl.c mm_lightc_ln.c mm_lightc_xyl.c
  group console
    ./app/: cli_krhino.c
